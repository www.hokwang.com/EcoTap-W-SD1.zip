Properties of the parts of a building model (IFC4)

# File
Description: IFC4
File name: EcoTap-W SD2.IFC
Time: 2022-01-04T03:23:32
Written by: SwIFC
Made in: SolidWorks 2021

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: A0130-0029_HK-CSDX3_轉角接頭
In: Default Storey
PredefinedType: ELEMENT; Material: PP 單聚物

# IfcBuildingElementProxy: A0130-0037_HK-CSDX3_皂液出皂口
In: Default Storey
PredefinedType: ELEMENT; Material: Steel

# IfcBuildingElementProxy: A0130-0060 EcoTap SD_出口固定上蓋
In: Default Storey
PredefinedType: ELEMENT; Material: Steel

# IfcBuildingElementProxy: A0130-0061 EcoTap SD_感應器及出皂口座_A1
In: Default Storey
PredefinedType: ELEMENT; Material: Steel

# IfcBuildingElementProxy: A0134-0004 EcoTap_出風管座
In: Default Storey
PredefinedType: ELEMENT; Material: Steel

# IfcBuildingElementProxy: A0134-0005 EcoTap_出風管座螺帽_Default
In: Default Storey
PredefinedType: ELEMENT; Material: Steel

# IfcBuildingElementProxy: A0134-0006 EcoTap_出風管導光塞頭_Default
In: Default Storey
PredefinedType: ELEMENT; Material: Steel

# IfcBuildingElementProxy: C0334-0005 EcoTap_華司
In: Default Storey
PredefinedType: ELEMENT; Material: Steel

# IfcBuildingElementProxy: C0334-0006 EcoTap_出風管導光塞頭飾板_Default
In: Default Storey
PredefinedType: ELEMENT; Material: Steel

# IfcBuildingElementProxy: F0230-0004 EcoTap SD_LED基板_Default
In: Default Storey
PredefinedType: ELEMENT; Material: Steel

# IfcBuildingElementProxy: F0330-0007 EcoTap SD_感應基板組_Default
In: Default Storey
PredefinedType: ELEMENT; Material: Steel

# IfcBuildingElementProxy: G0130-0019 EcoTap SD_出皂口迫緊_Default
In: Default Storey
PredefinedType: ELEMENT; Material: Steel

# IfcBuildingElementProxy: G0234-0002 EcoTap_出風龍頭墊片
In: Default Storey
PredefinedType: ELEMENT; Material: Steel

# IfcBuildingElementProxy: G0234-0003 EcoTap墊片
In: Default Storey
PredefinedType: ELEMENT; Material: Steel

# IfcBuildingElementProxy: Soap牆面式出皂管_38D-220-A2_Default
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 牆面式EcoTap出風管固定片
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 牆面式EcoTap出風管飾板_Default
In: Default Storey
PredefinedType: ELEMENT; Material: 0
